# Repository dsealand/spelunk

File README.md:

# spelunker

Learning KiCad and QMK to build a custom, Alice-ispired ortholinear keyboard

## KiCad design olice/test1.kicad_pcb

Parts:
C1: 1u; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4, C5: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C8: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47: D; D_SOD-123
D13: PRTR5V0U2X; SOT143B
F1: 500m; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: AVR-ISP-6; Reset_Pretty-Mask
K1, K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K15, K16, K17, K18, K19, K20, K21, K22, K23, K24, K25, K26, K27, K28, K29, K30, K31, K32, K33, K34, K35, K36, K37, K38, K39, K40, K41, K42, K43, K44, K45, K46: KEYSW; SW_Cherry_MX_1.00u_Plate
R1, R2: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_PUSH; SW_SPST_SKQG_WithStem
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
USB1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-HandSoldering
Y1: XTAL; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C3.1, C4.1, C5.1, C6.1, F1.1, J1.2 (VCC), R6.2, U1.2, U1.7, U1.14, U1.24, U1.34, U1.44
D+: R2.1, U1.4
D-: R1.1, U1.3
DN: D13.3 (I/O2), R1.2, USB1.5 (DN2), USB1.7 (DN1)
DP: D13.2 (I/O1), R2.2, USB1.6 (DP1), USB1.8 (DP2)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D13.1 (GND), J1.6 (GND), R3.2, R4.2, R5.1, SW1.1, U1.5, U1.15, U1.23, U1.35, U1.43, USB1.1 (GND), USB1.12 (GND), USB1.13 (SHIELD), Y1.2, Y1.4
MISO: J1.1 (MISO), U1.11
MOSI: J1.4 (MOSI), U1.10
unnamed: C1.1, U1.6
unnamed: D1.2 (A), K1.2
unnamed: D2.2 (A), K2.2
unnamed: D3.2 (A), K3.2
unnamed: D4.2 (A), K4.2
unnamed: D5.2 (A), K5.2
unnamed: D6.2 (A), K6.2
unnamed: D7.2 (A), K7.2
unnamed: D8.2 (A), K8.2
unnamed: D9.2 (A), K9.2
unnamed: D10.2 (A), K10.2
unnamed: D11.2 (A), K11.2
unnamed: D12.2 (A), K12.2
unnamed: D14.2 (A), K13.2
unnamed: D15.2 (A), K14.2
unnamed: D16.2 (A), K15.2
unnamed: D17.2 (A), K16.2
unnamed: D18.2 (A), K17.2
unnamed: D19.2 (A), K18.2
unnamed: D20.2 (A), K19.2
unnamed: D21.2 (A), K20.2
unnamed: D22.2 (A), K21.2
unnamed: D23.2 (A), K22.2
unnamed: D24.2 (A), K23.2
unnamed: D25.2 (A), K24.2
unnamed: D26.2 (A), K25.2
unnamed: D27.2 (A), K26.2
unnamed: D28.2 (A), K27.2
unnamed: D29.2 (A), K28.2
unnamed: D30.2 (A), K29.2
unnamed: D31.2 (A), K30.2
unnamed: D32.2 (A), K31.2
unnamed: D33.2 (A), K32.2
unnamed: D34.2 (A), K33.2
unnamed: D35.2 (A), K34.2
unnamed: D36.2 (A), K35.2
unnamed: D37.2 (A), K36.2
unnamed: D38.2 (A), K37.2
unnamed: D39.2 (A), K38.2
unnamed: D40.2 (A), K39.2
unnamed: D41.2 (A), K40.2
unnamed: D42.2 (A), K41.2
unnamed: D43.2 (A), K42.2
unnamed: D44.2 (A), K43.2
unnamed: D45.2 (A), K44.2
unnamed: D46.2 (A), K45.2
unnamed: D47.2 (A), K46.2
unnamed: R3.1, USB1.10 (CC2)
unnamed: R4.1, USB1.4 (CC1)
unnamed: R5.2, U1.33
RESET: J1.5 (~RST), R6.1, SW1.2, U1.13
SCK: J1.3 (SCK), U1.9
VCC: D13.4 (VCC), F1.2, USB1.2 (VBUS), USB1.11 (VBUS)
XTAL1: C7.1, U1.17, Y1.1
XTAL2: C8.1, U1.16, Y1.3
col0: K1.1, K13.1, K25.1, K37.1, U1.37
col1: K2.1, K14.1, K26.1, U1.38
col2: K3.1, K15.1, K27.1, K45.1, U1.27
col3: K4.1, K16.1, K28.1, K38.1, U1.28
col4: K5.1, K17.1, K29.1, K39.1, U1.29
col5: K6.1, K18.1, K30.1, K40.1, U1.30
col6: K7.1, K19.1, K31.1, K41.1, U1.19
col7: K8.1, K20.1, K32.1, K42.1, U1.20
col8: K9.1, K21.1, K33.1, K43.1, U1.21
col9: K10.1, K22.1, K34.1, K46.1, U1.22
col10: K11.1, K23.1, K35.1, U1.25
col11: K12.1, K24.1, K36.1, K44.1, U1.26
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.41
row1: D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), U1.40
row2: D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), U1.39
row3: D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), U1.36

Board: 2 copper layers, 249.9 x 88.1 mm, 112 parts (66 on the bottom side), 79 nets.

File spelunker/manufacturing/test1_bom.csv:

Id,Designator,Package,Quantity,Designation,Supplier and ref
2,"D47,D46,D45,D44,D43,D42,D41,D40,D39,D38,D37,D36,D35,D34,D33,D32,D31,D30,D29,D28,D27,D26,D25,D24,D23,D22,D21,D20,D19,D18,D17,D16,D15,D14,D12,D11,D10,D9,D8,D7,D6,D5,D4,D3,D2,D1",D_SOD-123,46,D,
3,C1,L_0805_2012Metric_Pad1.15x1.40mm_HandSolder,1,1u,
4,USB1,HRO-TYPE-C-31-M-12-HandSoldering,1,HRO-TYPE-C-31-M-12,
5,C6,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,1,10uF,
6,"C5,C4,C3",C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,3,0.1uF,
7,U1,TQFP-44_10x10mm_P0.8mm,1,ATmega32U4-AU,
8,"R5,R6",R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,2,10k,
9,D13,SOT143B,1,PRTR5V0U2X,
10,Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering,1,XTAL,
11,SW1,SW_SPST_SKQG_WithStem,1,SW_PUSH,
12,"R4,R3",R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,2,5.1k,
13,"R2,R1",R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,2,22,
14,J1,Reset_Pretty-Mask,1,AVR-ISP-6,
15,F1,Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder,1,500m,
16,"C8,C7",C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,2,22pF,

## Commit log

2021-03-26 changed usb connector to be flush with edge of keys
2021-04-15 completed ortho alice layout
2021-04-15 initial olice commit
2021-04-21 recreated updated gerbers with added keys on bottom row, recreated plate file with correct switch hole dimensions
2021-06-02 final pcb and production files:
2021-06-02 production files
2021-06-10 updated plate files with all 8 screw holes and more clearance
2021-06-10 deleted plunck, added firmware hex file
2021-06-10 created gitignore
2021-06-10 refactor
2021-06-10 keymap firmware update
2021-06-10 debugging matrix
2021-06-10 enabled console output
2021-06-10 enable debug
2021-06-10 removed polling rate debug
